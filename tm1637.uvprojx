# Keil uVision project tm1637.uvprojx, settings and files
target STM32F411RETx (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tm1637
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Main
    ./: main.c
  group Delay
    ./: delay.c delay.h
  group Clock_Config
    ./: SysClockConfig.c SysClockConfig.h
  group Encoder
    ./: encoder.h encoder.c
  group TM1637
    ./: TM1637.c TM1637.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
